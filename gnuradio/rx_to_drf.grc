options:
  parameters:
    author: Rainville
    generate_options: no_gui
    id: rx_to_drf
    output_language: python
  states: {}

blocks:
- name: center_f
  id: variable
  parameters:
    value: '0'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 76.8e6
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: short
    vlen: '2'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    maxoutbuf: '16384'
    minoutbuf: '8192'
    samples_per_second: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: gr_digital_rf_digital_rf_sink_0_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[center_f]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: sc16
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '512'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: '''now'''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: /mnt/ramdisk/drf_ring_buffer
    uuid: ''
    vlen: '1'
  states: {}
- name: network_udp_source_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
    vlen: '2'
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [blocks_throttle2_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle2_0, '0', gr_digital_rf_digital_rf_sink_0_0, '0']
- [network_udp_source_0_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

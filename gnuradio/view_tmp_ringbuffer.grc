options:
  parameters:
    generate_options: qt_gui
    id: view_tmp_ringbuffer
    output_language: python
    title: f"{samp_rate/1e6:n} MHz sample rate stream"
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: Center Frequency (Hz)
    type: real
    value: '0'
  states: {}
- name: channel
  id: variable
  parameters:
    value: '"chA"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Enable IShort To Complex when 64 MHz
    value: 1e6
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'True'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: f"/data/tmp-ringbuffer/sr{samp_rate/1e6:n}MHz/{channel}"
    end: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: int(samp_rate * 0.01)
    repeat: 'True'
    start: ''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '8192'
    grid: 'True'
    gui_hint: tabs@0
    type: complex
    update_time: '0.03'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 1090e6
    fftsize: '8192'
    rate: '30'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: tabs@1
    type: complex
    update_time: '0.05'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: Waterfall
    num_tabs: '2'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

options:
  parameters:
    author: Rainville
    generate_options: qt_gui
    id: rx_to_gui
    output_language: python
  states: {}

blocks:
- name: center_f
  id: variable
  parameters:
    value: 98.0e6
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 64e6
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    maxoutbuf: '66048'
    minoutbuf: '8192'
    scale_factor: '32767'
    vector_input: 'True'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.12'
    mintime: '2000.0'
    type: short
    vlen: '2'
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    maxoutbuf: '16384'
    minoutbuf: '8192'
    samples_per_second: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: network_udp_source_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    maxoutbuf: '16384'
    minoutbuf: '8192'
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
    vlen: '2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_f
    fftsize: '2048'
    gui_hint: tab_widget@0
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tab_widget@0
    size: '512'
    srate: samp_rate
    tr_level: '.05'
    type: complex
    ymax: '.5'
    ymin: '-.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_f
    fftsize: '2048'
    gui_hint: tab_widget@1
    type: complex
  states: {}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    label0: Tab0
    label1: Tab1
    num_tabs: '2'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [blocks_throttle2_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_probe_rate_0, '0']
- [network_udp_source_0_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

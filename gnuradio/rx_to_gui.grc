options:
  parameters:
    author: Rainville
    generate_options: qt_gui
    id: rx_to_gui
    output_language: python
  states: {}

blocks:
- name: center_f
  id: variable
  parameters:
    value: 38.4e6
  states: {}
- name: dec_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 76.8e6
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'True'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: short
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    maxoutbuf: 2*int(samp_rate)
    minoutbuf: int(samp_rate)
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate/dec_rate
    ctrlpanel: 'True'
    fc: center_f
    fftsize: '2048'
    gui_hint: tab_widget@0
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tab_widget@0
    size: '512'
    srate: samp_rate/dec_rate
    tr_level: '.05'
    type: complex
    ymax: '.5'
    ymin: '-.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/dec_rate
    fc: center_f
    fftsize: '2048'
    gui_hint: tab_widget@1
    type: complex
    update_time: '0.1'
  states: {}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    label0: Tab0
    label1: Tab1
    num_tabs: '2'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [network_udp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

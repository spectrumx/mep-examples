options:
  parameters:
    author: rainville
    generate_options: qt_gui
    id: rx_fm
    output_language: python
  states: {}

blocks:
- name: audio_dec_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: center_f
  id: variable
  parameters:
    value: 98.0e6
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 42.6666666e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec_rate
    quad_rate: audio_samp_rate*audio_dec_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_samp_rate)
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    maxoutbuf: '66048'
    minoutbuf: '8192'
    scale_factor: '32767'
    vector_input: 'True'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.1'
    mintime: '2000.0'
    type: short
    vlen: '2'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    maxoutbuf: '16384'
    minoutbuf: '8192'
    samples_per_second: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: network_udp_source_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    maxoutbuf: '16384'
    minoutbuf: '8192'
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
    vlen: '2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_f
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: audio_samp_rate*audio_dec_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: '3'
    maxoutbuf: '8191'
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [blocks_throttle2_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_throttle2_0, '0', blocks_probe_rate_0, '0']
- [network_udp_source_0_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

options:
  parameters:
    author: John Swoboda
    generate_options: qt_gui
    id: drf2zmq
    output_language: python
    title: Digital RF to ZeroMQ
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: drfdir
  id: parameter
  parameters:
    label: drfdir
    type: str
    value: '"/Users/swoboj/Documents/Python/spectrumx/mep_tx/example/txchan0"'
  states: {}
- name: en_time
  id: parameter
  parameters:
    label: en_time
    type: str
    value: '""'
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: drfdir
    end: en_time
    gapless: 'False'
    hide_msg_port: 'False'
    min_chunksize: '0'
    repeat: 'True'
    start: st_time
  states: {}
- name: pubaddr
  id: parameter
  parameters:
    label: pubaddr
    type: str
    value: '"tcp://127.0.0.1:5561"'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: '1000000'
  states: {}
- name: st_time
  id: parameter
  parameters:
    label: st_time
    type: str
    value: '""'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: pubaddr
    timeout: '100'
    type: short
    vlen: '2'
  states: {}

connections:
- [gr_digital_rf_digital_rf_channel_source_0, '0', zeromq_pub_sink_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, properties, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.7.0

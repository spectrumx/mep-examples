options:
  parameters:
    author: Rainville
    generate_options: qt_gui
    id: read_from_drf
    output_language: python
    title: read_from_drf
  states: {}

blocks:
- name: center_f
  id: variable
  parameters:
    value: '0'
  states: {}
- name: dec_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 76.8e6
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'True'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/dec_rate
    type: short
    vlen: '2'
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: ch0
    end0: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: ''
    throttle: 'False'
    top_level_dir: /data/drf_ring_buffer
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '512'
    srate: samp_rate/dec_rate
    tr_level: '.15'
    type: complex
    ymax: '.5'
    ymin: '-.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/dec_rate
    fc: center_f
    fftsize: '2048'
    type: complex
    update_time: '0.1'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

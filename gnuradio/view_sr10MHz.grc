options:
  parameters:
    generate_options: qt_gui
    id: view_sr10MHz
    output_language: python
    title: 10 MHz sample rate stream
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: tuner_freq + rfsoc_freq
  states: {}
- name: dec
  id: variable
  parameters:
    value: '4'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: samp_rate / dec
  states: {}
- name: rfsoc_freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.95 * samp_rate / dec / 2
    gain: '1.0'
    samp_rate: samp_rate
    width: 0.1 * samp_rate / dec
    win: window.WIN_HAMMING
  states: {}
- name: tuner_freq
  id: variable
  parameters:
    value: 7130e6
  states: {state: disabled}
- name: tuner_freq
  id: variable
  parameters:
    value: 5579.35e6
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: dec
    taps: taps
    type: ccc
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: /data/ringbuffer/mep/sr10MHz
    end: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'True'
    start: ''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: out_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '16384'
    grid: 'True'
    gui_hint: tabs@0
    norm_window: 'True'
    type: complex
    update_time: '0.05'
    ymax: '-75'
    ymin: '-105'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '30'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: out_rate
    color1: '1'
    fc: center_freq
    fftsize: '16384'
    gui_hint: tabs@1
    int_max: '-75'
    int_min: '-105'
    type: complex
    update_time: '0.05'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: Waterfall
    num_tabs: '2'
  states: {}

connections:
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

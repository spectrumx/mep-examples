options:
  parameters:
    generate_options: qt_gui
    id: view_sr20MHz
    output_language: python
    title: 20 MHz sample rate stream
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: /data/ringbuffer/mep/sr20MHz
    end: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'True'
    start: ''
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '30'
    type: complex
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

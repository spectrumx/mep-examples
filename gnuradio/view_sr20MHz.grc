options:
  parameters:
    generate_options: qt_gui
    id: view_sr20MHz
    output_language: python
    title: 20 MHz sample rate stream
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: tuner_freq + rfsoc_freq
  states: {}
- name: rfsoc_freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tuner_freq
  id: variable
  parameters:
    value: 6126.6e6
  states: {}
- name: tuner_freq
  id: variable
  parameters:
    value: 7130e6
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: /data/ringbuffer/mep/sr20MHz
    end: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'True'
    start: ''
  states: {state: disabled}
- name: gr_digital_rf_digital_rf_channel_source_0_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: /data/recordings/maser/sr20MHz
    end: '"2025-04-14T18:59:00"'
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'True'
    start: '"2025-04-14T18:57:00"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '16384'
    grid: 'True'
    gui_hint: tabs@0
    norm_window: 'True'
    type: complex
    update_time: '0.05'
    ymax: '-80'
    ymin: '-105'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '30'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: center_freq
    fftsize: '16384'
    gui_hint: tabs@1
    int_max: '-80'
    int_min: '-105'
    type: complex
    update_time: '0.05'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: Waterfall
    num_tabs: '2'
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_throttle2_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

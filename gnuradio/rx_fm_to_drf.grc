options:
  parameters:
    author: Rainville
    generate_options: no_gui
    id: rx_to_gui
    output_language: python
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: center_f
  id: variable
  parameters:
    value: 90.1e6
  states: {}
- name: dec_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 76.8e6
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: short
  states: {}
- name: gr_digital_rf_digital_rf_sink_0
  id: gr_digital_rf_digital_rf_sink
  parameters:
    center_freqs: '[center_f]'
    channel0: ch0
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: sc16
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    nchan: '1'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: '''now'''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    top_level_dir: /data/drf_fm_buffer
    uuid: ''
    vlen: '1'
  states: {}
- name: network_udp_source_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', gr_digital_rf_digital_rf_sink_0, '0']
- [network_udp_source_0_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
